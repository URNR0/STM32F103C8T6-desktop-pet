# Keil uVision project mypet.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: mypet
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\User;.\CMSIS;.\FWLIB\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./User/: main.c stm32f10x_it.c oled.c pet.c uart_cmd.c usart1.c delay.c
  group CMSIS
    ./CMSIS/: system_stm32f10x.c startup_stm32f10x_md.s
  group FWLIB
    ./FWLIB/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_i2c.c stm32f10x_usart.c misc.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_dma.c
